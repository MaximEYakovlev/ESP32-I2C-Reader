## sdkconfig.defaults
```kconfig
CONFIG_I2C_MASTER_SCL_IO=2
CONFIG_I2C_MASTER_SDA_IO=3
CONFIG_I2C_MASTER_FREQ_HZ=100000
```
